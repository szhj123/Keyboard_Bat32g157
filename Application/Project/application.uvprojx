# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: BAT32G157GK64FB Cmsemicon
  pack: Cmsemicon.BAT32G157.1.00.4
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Device\Include;..\..\Driver\inc;..\User;..\..\Usb_Driver\usb_driver\inc;..\..\Usb_Driver\usb_phid_apl\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../../Device/Source/ARM/: startup_BAT32G157.s
  group Cmsis
    ../../Device/Source/: system_BAT32G157.c
  group Library
    ../../Driver/src/: clk.c gpio.c
  group Usb_Driver
    ../../Usb_Driver/usb_driver/: usb_phid_driver.lib
    ../../Usb_Driver/usb_phid_apl/src/: usb_phid_driver.c
  group App
    ../User/: main.c app_usb_keyboard.c usb_keyboard_descriptor.c
  group Drv
    ../User/: drv_task.c drv_timer.c
  group Hal
    ../User/: hal_interrupt.c hal_task.c hal_timer.c
